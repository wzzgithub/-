# Keil uVision project Stm32f103Templete.uvprojx, settings and files
target Stm32f103Templete (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Stm32f103Templete +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe   --bin -o  ..\OutPut\Stm32f103Templete.bin ..\OutPut\Stm32f103Templete.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\StdPeriph_Driver\inc;..\CMSIS;..\Bsp\inc;..\windows;..\src;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x7d000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../app/: App.c stm32f10x_it.c
  group Bsp
    ../Bsp/src/: bsp_systick.c
  group CMSIS
    ../CMSIS/: system_stm32f10x.c
  group StartUp
    ../StartUp/: startup_stm32f10x_hd.s core_cm3.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
