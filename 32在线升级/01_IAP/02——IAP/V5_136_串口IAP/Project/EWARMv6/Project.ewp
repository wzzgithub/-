# IAR project Project.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\User\bsp_stm32f4xx; ..\..\User\bsp_stm32f4xx\inc; ..\..\User; ..\..\User\fonts
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  postbuild: CopyHex_Flash.bat
  ILINK.IlinkOutputFile: stm32-f4.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group BSP
    ../../User/bsp_stm32f4xx/: bsp.c stm32f4xx_assert.c stm32f4xx_it.c
    ../../User/bsp_stm32f4xx/src/: bsp_printf.c bsp_uart.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt 03.开发环境说明.txt 04.STM32F407IGT6引脚定义(原始定义).txt 05.GPIO分配表(按GPIO次序排列).txt 06.GPIO分配表(按功能排列).txt
  group EWARMv6
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group Fonts
    ../../User/fonts/: asc12.c asc16.c fonts.h hz12.c hz16.c
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group User
    ../../User/: common.c flash_if.c main.c ymodem.c
