# IAR project STM32F10x_IAP.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\..\include; ..\..\..\FWLib\library\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: STM32F10x_IAP.srec
  ILINK.IlinkOutputFile: STM32F10x_IAP.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_FLASH; USE_STM3210B_EVAL
  OBJCOPY.OOCOutputFile: myTeast_STM32F10x_IAP.hex
  group Application
    ../../source/: common.c download.c main.c stm32f10x_it.c ymodem.c
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c
