# Keil uVision project STM32F10x_IAP.uvprojx, settings and files
target STM3210B-EVAL (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210B-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210B_EVAL
  c include: ..\..\include;..\..\..\FWLib\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../../source/: common.c download.c main.c stm32f10x_it.c ymodem.c
  group FWLib
    ../../../FWLib/library/src/: stm32f10x_wwdg.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_nvic.c
  group RVMDK
    ./: startup_stm32f10x_hd.s sys.c core_cm3.c
target STM3210E-EVAL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM3210E-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STM3210E_EVAL
  c include: ..\..\include;..\..\..\FWLib\library\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
