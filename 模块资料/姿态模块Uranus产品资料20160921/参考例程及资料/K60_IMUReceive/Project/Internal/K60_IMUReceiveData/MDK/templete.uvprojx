# Keil uVision project templete.uvprojx, settings and files
target mk60d10 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: templete +hex
  c flags: Optim=1
  c define: MK60D10 RAVEN
  c misc: --c99
  c include: ..\..\..\..\Libraries\startup\inc;..\..\..\..\Libraries\drivers\inc;..\..\..\..\Libraries\utilities\inc;..\..\..\..\Libraries\devices\inc;..\..\..\..\Libraries\utilities\imu;..\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group startup_mk60d10
    ../../../../Libraries/startup/src/: system_MK60D10.c
    ../../../../Libraries/startup/src/mdk/: startup_MK60D10.s
  group user
    ../src/: main.c
  group drivers
    ../../../../Libraries/drivers/src/: common.c gpio.c uart.c
  group packet
    ../../../../Libraries/utilities/imu/: packet.c
